# Keil uVision project demo4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: demo4
  c flags: Optim=1
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Source Group 1
    ./: start.s

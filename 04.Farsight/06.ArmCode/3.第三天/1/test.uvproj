# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: test
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x40000000 size 0x2000
  scatter file: test.sct
  group Source Group 1
    ./: test.s
